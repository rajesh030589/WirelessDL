options:
  parameters:
    generate_options: qt_gui
    id: fm_block
    output_language: python
    run_options: run
    title: FM Receiver
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 2.2e9
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/rajesh/ICLRWork/WirelessDL/Python/Automation/RX.bin
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/rajesh/ICLRWork/WirelessDL/Python/Automation/TX.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '10000000'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '10000000'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    dev_addr: '"addr=192.168.20.2"'
    gain0: tx_gain
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq
    dc_offs_enb0: auto
    dev_addr: '"addr=192.168.20.2"'
    gain0: rx_gain
    iq_imbal_enb0: auto
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_head_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_head_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
